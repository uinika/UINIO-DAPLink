# Repository uinika/UINIO-DAPLink

File README.md:

# UINIO-DAPLink 下载调试器

[**UINIO-DAPLink**](https://gitee.com/uinika/UINIO-DAPLink) 是一款基于 [**ARM DAP Link**](https://daplink.io/) 开源固件的硬件下载调试电路设计，采用 `LQFP48` 封装的 **STM32F103CBT6** 或者 **STM32F103C8T6** 微控制器作为主控芯片，同时也兼容其它 `Pin to Pin` 的 **Cortex-M3** 微控制器（需要自行编译固件）。

## 设计概要

1. 清晰合理的丝印标识，并且预留有 `2mm` 直径的固定螺丝孔；
2. **USB Type-C** 接口位置新增一组 TVS 瞬态电压抑制二极管；
3. 对 `5V` 和 `3.3V` 电源采用了大面积铺铜处理，以提升载流能力。
4. 附带有 **SWD** 和 **JTAG** 协议的转接板，以及相关功能的跳线位；
5. 低压差线性稳压器 **LDO** 调整为南京微盟电子的 `ME6211C33M5G` 方案；
6. 专门为 `5V` 引脚接口添加了一组由保险丝和二极管组成的防反接电路；
7. 工程的 `Firmware` 目录已经编译好 [ARMmbed DAPLink](https://github.com/ARMmbed/mbed-HDK-Eagle-Projects) 提供的 [REL v0258](https://github.com/ARMmbed/DAPLink/releases/tag/v0258) 版本固件（包含 `Bootloader` 和 `Interface` 两个二进制文件）；

## 参考技术文档

[UinIO.com 电子技术实验室](http://uinio.com/) 为 **UINIO-DAP-Link** 开源项目提供了如下一系列技术参考资料：

- [《UINIO-DAPLink 核心板原理图》](http://uinio.com/my/works/UINIO-DAPLink/UINIO-DAPLink-Schematic.pdf)
- [《交互式 BOM 物料清单与 PCB 版图在线预览》](http://uinio.com/my/works/UINIO-DAPLink/UINIO-DAPLink-BOM.html)
- [《ARM 调试工具 UINIO-DAPLink 应用指南》](http://uinio.com/Project/UINIO-DAPLink/)

## KiCad design UINIO-DAPLink.kicad_pcb

Parts:
C1, C2: 1uF; C_0603_1608Metric
C3, C4: 20pF; C_0402_1005Metric
C5, C6, C7, C8, C9: 0.1uF; C_0402_1005Metric
C10: 1uF; C_0402_1005Metric
D1, D5: LED_Red; LED_0603_1608Metric
D2, D3, D4: LED_Blue; LED_0603_1608Metric
D6: 1N4007; Nexperia_CFP3_SOD-123W
D7, D8: LESD5D5.0CT1G; D_SOD-523
D9: LED Red; LED_0603_1608Metric
F1: 60V 1A; Fuse_1206_3216Metric
J1: 扩展板串口 & 电源输出; PinHeader_1x05_P2.54mm_Vertical
J2: 扩展板 JTAG 输出; IDC-Header_2x10_P2.54mm_Horizontal
J3: JTAG_nTRST 跳线选择; PinHeader_1x02_P2.54mm_Vertical
J4: 3.3V 跳线选择; PinHeader_1x02_P2.54mm_Vertical
J5: 扩展板 SWD 输入; PinSocket_1x11_P2.54mm_Vertical
J6: DAPLink 固件下载接口; PinHeader_1x05_P2.54mm_Vertical
J7: SWD 下载输出; PinSocket_1x11_P2.54mm_Vertical
R1, R2, R3, R15: 1.5K; R_0402_1005Metric
R4: 1K; R_0402_1005Metric
R6, R7, R8, R10, R11, R12: 10K; R_0402_1005Metric
R9: 100R; R_0402_1005Metric
R13, R14: 0R; R_0402_1005Metric
R16, R17: 5.1K; R_0603_1608Metric
U1: ME6211C33M5G; SOT-23-5_L3.0-W1.7-P0.95-LS2.8-BR
U2: STM32F103C8T6; LQFP-48_L7.0-W7.0-P0.50-LS9.0
USB1: USB_Type_C_16Pin; USB-C-SMD_TYPEC-304J-BCP16
Y1: 8MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
/Download_SWCLK: J6.2, U2.37 (PA14)
/Download_SWDIO: J6.3, U2.34 (PA13)
/JTAG_TCK/SWCLK: J7.8, U2.26 (PB13)
/JTAG_TDI: J7.6, U2.17 (PA7)
/JTAG_TDO: J7.5, U2.15 (PA5)
/JTAG_TMS/SWDIO: J7.9, R9.1, U2.27 (PB14)
/JTAG_nRST: J7.7, R7.1, U2.18 (PB0)
/NRST: C5.1, J6.1, R6.1, U2.7 (NRST)
/USART2_RX: J7.4, U2.13 (PA3)
/USART2_TX: J7.3, U2.12 (PA2)
/USB_+: D7.2 (A2), R13.2, USB1.A6 (DP1), USB1.B6 (DP2)
/USB_-: D8.2 (A2), R14.2, USB1.A7 (DN1), USB1.B7 (DN2)
/USB_Data_N: R14.1, U2.32 (PA11)
/USB_Data_P: R13.1, R15.2, U2.33 (PA12)
/USB_ENUM: U2.28 (PB15)
/VDD_3.3V: C2.1, C6.1, C7.1, C8.1, C9.1, C10.1, J6.5, J7.11, R4.2, R6.2, R7.2, R15.1, U1.5 (Vout), U2.1 (VBAT), U2.9 (VDDA), U2.24 (VDD_1), U2.36 (VDD_2), U2.48 (VDD_3)
/VDD_5V: F1.2, USB1.A4B9 (VBUS), USB1.B4A9 (VBUS)
/VDD_5V_Fuse: C1.1, D6.1 (K), F1.1, J7.1, U1.1 (Vin), U1.3 (CE)
/_JTAG_RTCK: J2.11
/_JTAG_TCK/SWCLK: J2.9, J5.8
/_JTAG_TDI: J2.5, J5.6
/_JTAG_TDO: J2.13, J5.5
/_JTAG_TMS/SWDIO: J2.7, J5.9
/_JTAG_TRST: J2.3
/_JTAG_nRST: J3.1, J5.7
/_JTAG_nRST_Output: J2.15, J3.2
/_USART2_RX: J1.1, J5.4, R3.2
/_USART2_TX: J1.2, J5.3, R2.2
/_VDD_3.3V: D1.2 (A), D2.2 (A), D3.2 (A), J1.3, J4.1, J5.11
/_VDD_3.3V_Output: J2.1, J2.2, J4.2
/_VDD_5V_Fuse: J1.5, J5.1
GND: C1.2, C2.2, C3.1, C4.1, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, D6.2 (A), D7.1 (A1), D8.1 (A1), D9.1 (K), J6.4, J7.2, J7.10, R8.2, R10.2, R11.2, R12.2, R16.1, R17.1, U1.2 (Vss), U2.8 (VSSA), U2.23 (VSS_1), U2.35 (VSS_2), U2.47 (VSS_3), USB1.13 (GND), USB1.14 (GND), USB1.15 (GND), USB1.16 (GND), USB1.A1B12 (GND), USB1.B1A12 (GND)
unnamed: C3.2, Y1.2
unnamed: C4.2, Y1.4
unnamed: D1.1 (K), R1.2
unnamed: D2.1 (K), R2.1
unnamed: D3.1 (K), R3.1
unnamed: D4.2 (A), U2.42 (PB6)
unnamed: D4.1 (K), R11.1
unnamed: D5.2 (A), U2.30 (PA9)
unnamed: D5.1 (K), R12.1
unnamed: D9.2 (A), R4.1
unnamed: R10.1, U2.44 (BOOT0)
unnamed: R8.1, U2.20 (PB2)
unnamed: R9.2, U2.25 (PB12)
unnamed: U2.5 (PD0-OSC_IN), Y1.3
unnamed: U2.6 (PD1-OSC_OUT), Y1.1
unnamed: R16.2, USB1.A5 (CC1)
unnamed: R17.2, USB1.B5 (CC2)
_GND: J1.4, J2.4, J2.6, J2.8, J2.10, J2.12, J2.14, J2.16, J2.18, J2.20, J5.2, J5.10, R1.1

Notes on the sheet:
SWD/JTAG 输出
SWD-JTAG 转接板
STM32F103C8T6 最小系统
DAPLink 固件下载
过流 & 防反接
USB Type-C 接口
ME6211C33M5G 线性稳压器

Board: 2 copper layers, 95.1 x 30.0 mm, 55 parts (0 on the bottom side), 47 nets.

Other parts of the board:
HOLE**: Hole-2mm
HOLE**#2, HOLE**#3, HOLE**#4, HOLE**#5, HOLE**#6, HOLE**#7, HOLE**#8: Hole-2mm

## Commit log

2022-10-25 Initialization project.
2022-10-25 Add README.md
2022-10-27 Start schematic drawing work.
2022-10-28 Update extends board design.
2022-10-31 Update PCB.
2022-11-03 Update PCB layout.
2022-11-04 Preliminarily completed the PCB layout.
2022-11-07 Release UINIO-DAP-Link 1.0.0.
2022-11-13 Update design.
2022-11-14 Prepare Version 2.0.0.
2022-11-16 Release UINIO-DAP-Link 2.0.0.
2022-12-07 Release UINIO-DAP-Link 3.0.0.
2022-12-21 Fix bug.
2022-12-23 Release UINIO-DAP-Link version 3.0.1.
2023-01-11 Release UINIO-DAP-Link version 3.0.0.
2023-02-06 Release UINIO-DAP-Link version 3.2.0.
2023-06-29 Prepare version 3.3.0.
2023-06-30 Release UINIO-DAP-Link version 3.3.0.
2023-07-11 Update README.md.
2024-01-11 Release UINIO-DAP-Link version 3.3.1.
2024-01-12 Fix some problems.
2024-10-22 Finish PCB Layout.
2024-10-23 Release UINIO-DAPLink version 5.0.0.
2024-10-23 Release UINIO-DAPLink verison 5.0.0.
